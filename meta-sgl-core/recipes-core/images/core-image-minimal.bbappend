IMAGE_INSTALL:append = " \
    avahi-daemon \
    avahi-utils \
    libnss-mdns \
"

IMAGE_FEATURES:append = " \
   ssh-server-openssh \
"
